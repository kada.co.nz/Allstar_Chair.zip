Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-11T13:13:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 11 13:13:53 2019 * Host: DESKTOP-PKIN6P4 * Database: C:\Users\Pichau\AppData\Local\Temp\{AFFC8964-E882-4272-9855-E3C598A20E2A}\ifc * Database version: 5507 * Database creation date: Fri Jan 11 13:13:52 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 11 13:13:52 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 11 13:13:52 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Allstar Chair, CONV_Vitra_OffcChrs_Allstar:Allstar Chair:220127
In: Level 1
Material: 12 Deep black, Textile hopsak blue moor, Textile hopsak nero, Chrome
Pset_ManufacturerTypeInformation - ModelReference: 41900100; Manufacturer: Vitra
Constraints - BaseHeight: 203.2 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.57452 m2; SeatHeight: 420 mm; SeatHeight_Control: 420 mm; Volume: 0.378228 m3
Materials and Finishes - OfficeChairMainMaterial: Textile hopsak blue moor; OfficeChairSecondaryMaterial: Textile hopsak nero; OfficeChairTertiaryMaterial: 12 Deep black
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_OffcChrs_Allstar: Allstar Chair; Family and Type: CONV_Vitra_OffcChrs_Allstar: Allstar Chair; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_OffcChrs_Allstar: Allstar Chair; Type Id: CONV_Vitra_OffcChrs_Allstar: Allstar Chair; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_OffcChrs_SoftPadChair_EA217; ConvergoRefNr: 0089-1812-0155-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: The Allstar office chair by Konstantin Grcic imparts a relaxed home-like feel and sense of familiarity. Its rounded form exudes comfort and yields a calming influence on the fast-paced dynamic of today's offices. Allstar also satisfies all the necessary functions of a task chair, allowing it to be used wherever high functional performance is desired but a classic office chair would not be appropriate for aesthetic reasons – an especially ideal choice for modern workplace concepts.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 10/01/2019
Identity Data(Type) - Collection: Allstar; Cost: 0; Description: The Allstar office chair by Konstantin Grcic imparts a relaxed home-like feel and sense of familiarity. Its rounded form exudes comfort and yields a calming influence on the fast-paced dynamic of today's offices. Allstar also satisfies all the necessary functions of a task chair, allowing it to be used wherever high functional performance is desired but a classic office chair would not be appropriate for aesthetic reasons – an especially ideal choice for modern workplace concepts.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Allstar Chair; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/854608/storage/master/download/Factbook%20Allstar-EN.pdf; Type Name: Allstar Chair; URL: https://www.vitra.com/en-un/office/product/details/allstar
Materials and Finishes(Type) - OfficeChairQuaternaryMaterial: Chrome; OfficeChairQuinaryMaterial: 12 Deep black
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_OffcChrs_Allstar; Features: Allstar contains all the functions necessary for an office chair according to current standards: a synchronised mechanism, seat depth and height adjustment, and an adjustable backrest that can be locked in the upright position. Functional features: seat height; seat depth; locking mechanism; backrest (upright position); backrest height.; Finish: Backrest and seat: backrest in polyamide, coated with polyurethane foam. Seat with contouring on the front edge, consisting of a polyamide seat plate, polyurethane foam and a seat cover stretched over the surface in fabric or leather. Armrest/back bracket: loop frame made of polyamide, available in 4 colours. Mechanical unit: in plastic (deep black). Base: five-star base in polyamide (deep black).; Grade: n/a; Material: Aluminium, polyamide, textile & polyurethane; ModelNumber: n/a; ModelReference: 41900100; Name: OffcChrs_SoftPadChair_EA217; ReplacementCost: n/a; Shape: Sculptured; Size: 610x495/740x785/955 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
